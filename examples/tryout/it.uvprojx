# Keil uVision project it.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: it
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS Driver Validation:Framework 1.4.0, CMSIS Driver Validation:USART 1.4.0, RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Message Buffer 10.3.1, RTOS:Stream Buffer 10.3.1, RTOS:Timers 10.3.1, CMSIS Driver:USART:Custom 2.3.0, CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, CMSIS:RTOS2:FreeRTOS 10.3.1, mbed:minar 1.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0, Device:STM32Cube HAL 1.7.0, CMSIS Driver:USART:USART Async 1.0.0
