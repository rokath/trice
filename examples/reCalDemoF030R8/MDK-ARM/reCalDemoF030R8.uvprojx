# Keil uVision project reCalDemoF030R8.uvprojx, settings and files
target reCalDemoF030R8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: reCalDemoF030R8 +hex
  BeforeMake: trice u -src ../../.. -list ../../til.json
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F030x8
  c include: ../Inc;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.0/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.0/Drivers/CMSIS/Include;..\..\lib;..\..\..\src.C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Trice
    ../../../src.C/: trice.c
  group lib
    ../../lib/: Fifo.c msTicks.c printf.c RcPack.c RcRegistry.c triceCheck.c
software components: CMSIS:CORE 4.3.0
