<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\triceDemo_NUCLEO-F070RB_HAL_IAR_EWARM.ewp</path>
  </project>
  <batchBuild />
</workspace>
