<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_BARE_STM32F091_NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_BARE_STM32F091_NUCLEO-64.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_BARE_STM32F030R8-NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_BARE_STM32F030R8-NUCLEO-64.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_BARE_STM32F070RB_NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_BARE_STM32F070RB_NUCLEO-64.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_ESC_STM32F030R8_NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_ESC_STM32F030R8_NUCLEO-64.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_ESC_STM32F070RB_NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_ESC_STM32F070RB_NUCLEO-64.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_RTT0_BARE_STM32F0308-DISCO\MDK-ARM\MDK-ARM_RTT0_BARE_STM32F0308-DISCO.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_RTT0_BARE_STM32F03051R8Tx-DISCOVERY\MDK-ARM\MDK-ARM_RTT0_BARE_STM32F03051R8Tx-DISCOVERY.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\MDK-ARM_LL_UART_RTT0_WRAP_STM32F030R8-NUCLEO-64\MDK-ARM\MDK-ARM_LL_UART_RTT0_WRAP_STM32F030R8-NUCLEO-64.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
