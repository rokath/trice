# Keil uVision project MDK-ARM_STM32G031K8.uvprojx, settings and files
target MDK-ARM_STM32G031K8 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G031K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: MDK-ARM_STM32G031K8 +hex
  BeforeMake: trice u -v -li ../../../li.json  -i ../../../til.json -src ./ -src ../Core -src ../../../pkg/src
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G031xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\..\..\pkg\src;..\..\..\third_party\segger.com\SEGGER_RTT\RTT;..\..\..\third_party\cJSON-1.7.15;..\..\..\third_party\TCOBSv1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_pwr.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Trice
    ../../../pkg/src/: trice.c triceCheck.c
    ../../../third_party/segger.com/SEGGER_RTT/RTT/: SEGGER_RTT.c
    ../../../third_party/cJSON-1.7.15/: cJSON.c cJSON_Utils.c
    ../../../third_party/TCOBSv1/: tcobsEncode.c
software components: CMSIS:CORE 5.5.0
