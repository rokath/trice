# Keil uVision project MDK-ARM_STM32G071RB.uvprojx, settings and files
target MDK-ARM_STM32G071RB (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: MDK-ARM_STM32G071RB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6LangP=9 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx
  c include: ../Core/Inc;..\..\..\src;..\..\..\third_party\segger.com\SEGGER_RTT\RTT;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_ll_pwr.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_dma.c stm32g0xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Trice
    ../../../third_party/segger.com/SEGGER_RTT/RTT/: SEGGER_RTT.c
    ../../../src/: cobs.c tcobsv1Decode.c tcobsv1Encode.c trice.c triceCheck.c triceDoubleBuffer.c triceStackBuffer.c triceStreamBuffer.c xtea.c
software components: CMSIS:CORE 5.6.0
