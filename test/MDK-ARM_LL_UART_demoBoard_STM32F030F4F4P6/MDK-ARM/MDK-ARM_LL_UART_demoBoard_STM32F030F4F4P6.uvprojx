# Keil uVision project MDK-ARM_LL_UART_demoBoard_STM32F030F4F4P6.uvprojx, settings and files
target MDK-ARM_LL_UART_demoBoard_STM32F030F4F4P6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: MDK-ARM_LL_UART_demoBoard_STM32F030F4F4P6 +hex
  BeforeMake: trice u -src .. -src ../../../srcTrice.C -i ../../til.json -v
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRICE_VARIANT=STM32_LL,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F030x6
  c include: ../Inc;  C:/ST/CubeMX/STM32Cube_FW_F0_V1.11.0/Drivers/STM32F0xx_HAL_Driver/Inc;  C:/ST/CubeMX/STM32Cube_FW_F0_V1.11.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include;  C:/ST/CubeMX/STM32Cube_FW_F0_V1.11.0/Drivers/CMSIS/Include;  ..\..\..\srcTrice.C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Trice
    ../../../srcTrice.C/: trice.c triceCheck.c tricePrintfAdapter.c triceRuntimeGeneratedStrings.c triceWrite.c xteaCrypto.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c
  group Drivers/STM32F0xx_HAL_Driver
    C:/ST/CubeMX/STM32Cube_FW_F0_V1.11.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
