# Keil uVision project MDK-ARM_STM32F030R8.uvprojx, settings and files
target MDK-ARM_STM32F030R8 (6160000::V6.16::ARMCLANG)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: MDK-ARM_STM32F030R8 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F030x8
  c include: ../Core/Inc;..\..\..\src;..\..\..\third_party\segger.com\SEGGER_RTT\RTT;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/CMSIS/Device/ST/STM32F0xx/Include;C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/CMSIS/Include;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_it.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Trice
    ../../../third_party/segger.com/SEGGER_RTT/RTT/: SEGGER_RTT.c
    ../../../src/: trice.c triceCheck.c tcobsv1Encode.c xtea.c triceStreamBuffer.c triceDoubleBuffer.c triceStackBuffer.c cobs.c trice8.c trice16.c trice32.c trice64.c
software components: CMSIS:CORE 5.5.0
