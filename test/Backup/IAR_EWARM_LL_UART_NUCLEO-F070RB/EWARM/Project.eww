<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IAR_EWARM_LL_UART_NUCLEO-F070RB.ewp</path>
  </project>
  <batchBuild />
</workspace>
