<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IAR_EWARM_RTT_NUCLEO-F030R8.ewp</path>
  </project>
  <batchBuild />
</workspace>
