# IAR project IAR_EWARM_RTTD_DISCOVERY-STM32F407VGTx.ewp, settings and files
configuration IAR_EWARM_RTTD_DISCOVERY-STM32F407VGTx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; TRICE_VARIANT=SEGGER_RTTD_ASM
  ICCARM.CCIncludePath2: ../Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Middlewares/ST/STM32_USB_Host_Library/Core/Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Drivers/CMSIS/Include; ..\..\..\third_party\SEGGER_RTT_V672b\RTT; ..\..\..\srcTrice.C
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_EWARM_RTTD_DISCOVERY-STM32F407VGTx.hex
  prebuild: trice u -src .. -src ../../srcTrice.C -list ../../til.json
  ILINK.IlinkOutputFile: IAR_EWARM_RTTD_DISCOVERY-STM32F407VGTx.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_host.c usbh_conf.c usbh_platform.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Host_Library
    ../../../../../Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
    ../../../../../Users/ms/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.0/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group SeggerRTT
    ../../../third_party/SEGGER_RTT_V672b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Trice
    ../../../srcTrice.C/: trice.c trice.h triceCheck.c triceCheck.h triceConfig.h triceConfigCompiler.h triceConfigCriticalSection.h triceConfigTx.h triceConfigTxInterrupt.h tricePrintfAdapter.c triceRuntimeGeneratedStrings.c triceTick.h triceWrite.h triceWriteSeggerRTT.c
