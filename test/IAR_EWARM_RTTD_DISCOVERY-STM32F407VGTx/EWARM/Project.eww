<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IAR_EWARM_RTTD_DISCOVERY-STM32F407VGTx.ewp</path>
  </project>
  <batchBuild />
</workspace>
