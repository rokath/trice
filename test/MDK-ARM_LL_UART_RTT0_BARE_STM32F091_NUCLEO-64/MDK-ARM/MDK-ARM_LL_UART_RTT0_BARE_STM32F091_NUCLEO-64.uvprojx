# Keil uVision project MDK-ARM_LL_UART_RTT0_BARE_STM32F091_NUCLEO-64.uvprojx, settings and files
target MDK-ARM_LL_UART_RTT0_BARE_STM32F091_NUCLEO-64 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: MDK-ARM_LL_UART_RTT0_BARE_STM32F091_NUCLEO-64 +hex
  BeforeMake: trice u -i ../../../til.json -src ../../../ -v
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F091xC
  c include: ../Core/Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/STM32F0xx_HAL_Driver/Inc; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/CMSIS/Device/ST/STM32F0xx/Include; C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/CMSIS/Include; ..\..\..\srcTrice.C; ..\..\..\third_party\segger.com\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_it.c
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/ms/STM32Cube/Repository/STM32Cube_FW_F0_V1.11.2/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group trice
    ../../../srcTrice.C/: triceBareFifo.c triceBareFifoToBytesBuffer.c triceCheck.c triceSeggerRTT.c
    ../../../third_party/segger.com/SEGGER_RTT/RTT/: SEGGER_RTT.c
